options:
  parameters:
    author: Matt
    generate_options: qt_gui
    id: test
    output_language: python
    title: test
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: samp_rate/dec
  states: {}
- name: dec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq_tune
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: 1e2
    stop: 35e6
    value: 10e6
    widget: eng_slider
  states: {}
- name: rf_center
  id: variable
  parameters:
    value: '17500000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000.0'
  states: {}
- name: tunedChannel
  id: variable
  parameters:
    value: rf_center-freq_tune
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    type: raw
    value: tunedChannel
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\bailems1\roofTesting\M20009_10MHz_Audio
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_1_0
  id: blocks_file_source
  parameters:
    file: /Users/chartat1/superdarn/digital_rf_tools/combined.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 800*5
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tunedChannel
    decim: dec
    samp_rate: samp_rate
    taps: |
      firdes.low_pass(5.0, samp_rate, 10e3, 3e3)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3.8e3
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: rf_center
    fftsize: '4096'
    type: complex
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: audio_rate
    fc: '0'
    fftsize: '8192'
    type: float
    update_time: '0.001'
    ymax: '-30'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_rate
    fc: freq_tune
    fftsize: '2048'
    grid: 'True'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rf_center
    fftsize: '4096'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    int_max: '-30'
    type: float
    update_time: '.001'
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/dec)
    interp: audio_rate
    type: fff
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0_1_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
